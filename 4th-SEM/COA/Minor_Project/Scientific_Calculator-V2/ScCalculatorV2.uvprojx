# Keil uVision project ScCalculatorV2.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: ScCalculatorV2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --library_type=microlib
  group Source Group 1
    ./: calculator.s main.c startup_ARMCM4.s retarget.c
    C:/Keil_v5/ARM/Pack/ARM/CMSIS/4.5.0/Device/ARM/ARMCM4/Source/: system_ARMCM4.c
